# linux-raspberrypi.bbappend

# Override the VC4DTBO variable to use FKMS instead of KMS
VC4DTBO = "vc4-fkms-v3d"
